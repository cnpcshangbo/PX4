## src/examples/px4_simple_app2/Kconfig
```kconfig
menuconfig EXAMPLES_PX4_SIMPLE_APP2
	bool "px4_simple_app2"
	default n
	---help---
		Enable support for px4_simple_app2
```
